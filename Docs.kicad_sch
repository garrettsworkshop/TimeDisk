File: Docs.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Final GW4206A revision
Other:
- title: Time Machine -> TimeDisk
